# Keil uVision project Pjet_uC_CASR.uvprojx, settings and files
target Simulation (6230000::V6.23::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pjet_uC_CASR
  c flags: Optim=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c define: LCD_SIMULATOR
  c include: .\Service;.\src;.\Pilotes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group src
    ./src/: Principal.c
  group Services
    ./Service/: TimeManagement.c StringFct_2024.c LCD_Balance.c ToolBox_NRJ_uC_Interface.c
  group Pilotes
    ./Pilotes/: Clock_F103.c Lib_IO_ITExt_ADC_TIM_2024a.lib
target Cible_STlink_F103 (6220000::V6.22::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: as above
  output: Pjet_uC_CASR
  c flags: Optim=1 OneElfS=1 uC99=1 v6LangP=3 wLevel=2
  c include: .\Service;.\src;.\Pilotes
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
